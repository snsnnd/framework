# Keil uVision project hwtest.uvprojx, settings and files
target hwtest (6210000::V6.21::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: hwtest +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c misc: -include stdbool.h
  c include: ..\..\include;..\..\src;..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\hwtest.scat
  link misc: --entry=Reset_Handler
  group EFW
    ../../src/: efw_all.c
  group BSP
    ../: startup.c bsp.c
  group App
    ../: tests.c lcd.c stress.c dashboard.c game.c boundary.c
